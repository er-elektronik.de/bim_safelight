Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ST-6 EKW 25m.IFC
Time: 2022-03-04T11:04:45
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Acrylscheibe 10mm_EKW 25m
In: Default Storey
SolidWorks Custom Properties - Material: Acrylglas; Gewicht: 403.33; Version 1: EKW 17m; Version 2: EKW 25m; Version 3: EKW 34m

# IfcBuildingElementProxy: Avatara Montagefläche
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Avatara Technik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AX3 - AT.DS & BS,LFP 1,6Ah 3h 140Lm; Version 2: AX3DA - AT.DS&BS, LFP 1,6Ah,3h 140Lm DLI; Version 3: AX8 - AT.DS & BS,LFP 3,2Ah 8h 140Lm; Version 4: AX8DA - AT.DS&BS, LFP 3,2Ah,8h 140Lm DLI; Version 5: C - zentr. Vers. AC/DC Adressmodul; Version 6: E - für zentrale Versorgung AC/DC; Version 7: FM3 - AT.DS&BS,LFP 3,2V 3h RC250; Version 8: FM8 - AT.DS&BS,LFP 3,2V 8h RC250

# IfcBuildingElementProxy: Oberschale E-Box BIM_660011100 Oberschale E-Box weiß
In: Default Storey
Material: PBTP
SolidWorks Custom Properties - Material: PBTP; Gewicht: 94.51

# IfcBuildingElementProxy: ST Profil BIM_Safelight Profil 25m
In: Default Storey
SolidWorks Custom Properties - Material: AL Mg Si 0,5

# IfcBuildingElementProxy: Safelight Endkappe BIM_Safelight Endkappe (2)
In: Default Storey
SolidWorks Custom Properties - Material: PA 66; Gewicht: 0.71

# IfcBuildingElementProxy: Safelight Folien BIM_Piktofolie EKW 25m (2)
In: Default Storey
SolidWorks Custom Properties - Version 1: 00 - Piktogrammfolien f. Sonderpikto; Version 2: 20 - Piktoset LMU/R/L/Blind DIN7010; Version 3: 24 - Piktoset LM-OR/UL-UR/UL (7010); Version 4: 29 - Auslegerpiktos LMU/U/R/L(7010)

# IfcBuildingElementProxy: Unterschale E-Box BIM
In: Default Storey
Material: PBTP
SolidWorks Custom Properties - Material: PBTP; Gewicht: 105.70

# IfcElementAssembly: ST-6 EKW 25m
In: Default Storey
SolidWorks Custom Properties - Farbe 1: weiß; Farbe 2: silber
PSet_Mass_Property - Mass Measure: 0.693838; Area Measure: 0.505237 m2; Volume Measure: 0.000539088 m3

# IfcElementAssembly: Safelight BIM_Safelight 25m
In: Default Storey
SolidWorks Custom Properties - Version 1: EKW 17m; Version 2: EKW 25m; Version 3: EKW 34m
